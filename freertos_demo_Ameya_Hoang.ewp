# IAR project freertos_demo_Ameya_Hoang.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.1.4.178\examples\boards\ek-tm4c123gxl\freertos_demo; C:\ti\TivaWare_C_Series-2.1.4.178\examples\boards\ek-tm4c123gxl; C:\ti\TivaWare_C_Series-2.1.4.178\examples\boards\ek-tm4c123gxl\include; C:\ti\TivaWare_C_Series-2.1.4.178\examples\boards\ek-tm4c123gxl\third_party
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../freertos_demo - revised by Ameya/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../freertos_demo - revised by Ameya/: freertos_demo.c freertos_demo.sct FreeRTOSConfig.h led_task.c led_task.h port.c portmacro.h priorities.h startup_ccs.c startup_ewarm.c startup_gcc.c startup_rvmdk.S switch_task.c switch_task.h
