# IAR project LCD_lab.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: C:\TI-CMSIS-Devices-8636\TI\LM4F; C:\ti\TivaWare_C_Series-2.1.4.178
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: addresses.h addresses_3.h cstartup_M.c main.c part3.c PLL.c PLL.h SSD2119.c SSD2119.h tm4c123gh6pm.h
